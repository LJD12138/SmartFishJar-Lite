# Keil uVision project APP.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: $PMergeTool.bat $K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Firmware\CMSIS;.\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;.\Middlewares\FreeRTOS\include;.\Middlewares\SeggerRtt;.\ComFunc;.\Application;.\Hardware;.\Hardware\BSP;.\Middlewares\CmBacktrace;.\Middlewares\CmBacktrace\Languages\zh-CN;.\Middlewares\LightweightRingBuffer\src;.\Middlewares\EasyLogger\inc;.\Middlewares\EasyLogger\plugins\flash;.\Middlewares\EasyFlash\inc;.\Middlewares\Protocol;.\Middlewares\U8g2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group MW-FreeRTOS
    ./Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group MW-EasyFlash
    ./Middlewares/EasyFlash/src/: easyflash.c ef_env.c ef_iap.c ef_log.c ef_utils.c
    ./Middlewares/EasyFlash/port/: ef_port.c
  group MW-U8g2
    ./Middlewares/U8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts_min.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group MW-EasyLogger
    ./Middlewares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_Init.c elog_utils.c
    ./Middlewares/EasyLogger/port/: elog_port.c
    ./Middlewares/EasyLogger/plugins/flash/: elog_flash.c elog_flash_port.c
  group MW-CmBacktrace
    ./Middlewares/CmBacktrace/: cm_backtrace.c
    ./Middlewares/CmBacktrace/fault_handler/keil/: cmb_fault.S
  group MW-SeggerRtt
    ./Middlewares/SeggerRtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group MW-Protocol
    ./Middlewares/Protocol/Modbus/: modbus_proto.c modbus_proto.h
    ./Middlewares/Protocol/BaiKu/: baiku_proto.c baiku_proto.h
    ./Middlewares/Protocol/: proto_updata.c proto_updata.h
  group MW-Lwrb
    ./Middlewares/LightweightRingBuffer/src/: lwrb.c lwrb_ex.c
  group ComFunc
    ./ComFunc/: check.c filtration.c function.c i2c.c ntc.c queue_task.c
  group Application
    ./Application/: board_config.h FreeRTOSConfig.h main.c board_config.c app_info.c gpio_init.c fwdgt.c gd32f30x_it.c timer_task.c
  group App-Sys
    ./Application/Sys/: sys_task.c sys_task.h sys_queue_task.c sys_queue_task.h sys_queue_task_init.c sys_queue_task_closing.c sys_queue_task_shut_down.c sys_queue_task_booting.c sys_queue_task_work.c sys_queue_task_err.c sys_queue_task_reset.c sys_queue_task_eng.c sys_queue_task_eng.h sys_queue_task_updata.c sys_queue_task_updata.h
  group HW-Flash
    ./Hardware/Flash/: flash_gd32.c flash_iface.c
  group HW-Print
    ./Hardware/Print/: print_task.c print_task.h print_queue_task.c print_queue_task.h print_queue_task_main.c print_queue_task_reply_cali.c print_queue_task_reply_app_info.c print_queue_task_updata.c print_prot_frame.c print_prot_frame.h print_api.c print_api.h print_iface.c print_iface.h
  group HW-Adc
    ./Hardware/Adc/: adc_task.c adc_task.h adc_iface.c adc_iface.h
  group HW-Key
    ./Hardware/Key/: key_task.c key_task.h key_func.c key_func.h key_func_eng.c key_func_eng.h
  group HW-Buz
    ./Hardware/Buz/: buz_task.c buz_task.h buz_iface.c buz_iface.h
  group HW-Dc
    ./Hardware/Dc/: dc_task.c dc_task.h dc_iface.c dc_iface.h
  group HW-Usb
    ./Hardware/Usb/: usb_task.c usb_task.h usb_iface.c usb_iface.h usb_prot_frame.c usb_prot_frame.h usb_queue_task.c usb_queue_task.h usb_queue_task_booting.c usb_queue_task_closing.c usb_queue_task_err.c usb_queue_task_init.c usb_queue_task_work.c
  group HW-Led
    ./Hardware/Led/: led_task.c led_task.h led_iface.c led_iface.h
  group HW-MD_Display
    ./Hardware/MD_Display/: md_display_task.c md_display_task.h md_display_api.c md_display_api.h md_display_iface.c md_display_iface.h md_display_eng_mode.c md_display_eng_mode.h md_display_err.c md_display_queue_task.c md_display_queue_task.h md_display_queue_task_booting.c md_display_queue_task_closing.c md_display_queue_task_eng.c md_display_queue_task_err.c md_display_queue_task_init.c md_display_queue_task_shut_down.c md_display_queue_task_updata.c md_display_queue_task_work.c
  group HW-MD_Light
    ./Hardware/MD_Light/: md_light_task.c md_light_task.h md_light_iface.c md_light_iface.h
  group HW-MD_HeatManage
    ./Hardware/MD_HeatManage/: md_hm_task.c md_hm_task.h md_hm_iface.c md_hm_iface.h
  group HW-O2Pump
    ./Hardware/O2Pump/: o2pump_iface.h o2pump_task.c o2pump_task.h
  group HW-Pump
    ./Hardware/Pump/: pump_iface.c pump_iface.h pump_task.c pump_task.h
